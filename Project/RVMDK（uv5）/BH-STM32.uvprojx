# Keil uVision project BH-STM32.uvprojx, settings and files
target dht11 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=1 oTime=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\SYSTEM\delay;..\..\SYSTEM\usart;..\..\SYSTEM\sys;..\..\HARDWARE\IIC;..\..\HARDWARE\KEY;..\..\HARDWARE\LD3320;..\..\HARDWARE\MAX30102;..\..\HARDWARE\max30102_algorithm;..\..\HARDWARE\OLED;..\..\HARDWARE\word;..\..\User\ESP8266;..\..\User\SysTick;..\..\User\Common;..\..\User\Beep;..\..\User\dht11;..\..\User\dwt_delay;..\..\User\Led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/dht11/: bsp_dht11.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/font/: fonts.c
    ../../User/lcd/: bsp_ili9341_lcd.c
    ../../User/ldr/: bsp_ldr.c
    ../../User/Led/: bsp_led.c
    ../../User/ESP8266/: bsp_esp8266.c bsp_esp8266_test.c
    ../../User/Beep/: bsp_beep.c
    ../../User/Common/: Common.c
    ../../User/usart/: bsp_usart1.c
  group DOC
    ../../Doc/: readme.txt
  group SYSTEM
    ../../SYSTEM/delay/: delay.c
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
  group HARDWARE
    ../../HARDWARE/IIC/: IIC.c
    ../../HARDWARE/MAX30102/: max30102.c
    ../../HARDWARE/max30102_algorithm/: 30102_algorithm.c
    ../../HARDWARE/OLED/: oled.c
    ../../HARDWARE/word/: word.c
    ../../HARDWARE/LD3320/: LDChip.c Reg_RW.c
